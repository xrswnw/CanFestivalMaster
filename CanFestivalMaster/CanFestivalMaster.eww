<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Boot\CanFestivalMaster\Boot.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\CanFestivalMaster.ewp</path>
    </project>
    <batchBuild />
</workspace>
