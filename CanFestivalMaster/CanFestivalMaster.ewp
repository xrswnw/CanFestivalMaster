# IAR project CanFestivalMaster.ewp, settings and files
configuration Build (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xC GD GD32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; _ANYID_GD32_; _ANYID_HSE12P00_; _ANYID_BOOT_GD32_
  ICCARM.CCIncludePath2: ..\; ..\inc; E:\AnyID\AnyID_Embedded\V1.1.0\STM32_lib_V3.3\startup; E:\AnyID\AnyID_Embedded\V1.1.0\STM32_lib_V3.3\inc; E:\AnyID\AnyID_Embedded\V1.1.0\AnyID_lib_V1.1.0\inc; ..\CanFestival; ..\CanFestival\driver; ..\CanFestival\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CanFestivalSlave.hex
  ILINK.IlinkOutputFile: CanFestivalSlave.out
  ILINK.IlinkIcfFile: GD32F103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CanFestival
    ../CanFestival/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group CMSIS
    ../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/startup/: system_stm32f10x.c
  group EWARMv5
    ../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/startup/: startup_stm32f10x_hd.s
  group Main
    ../: main.c stm32f10x_conf.h stm32f10x_it.c
  group StdPeriph_Driver
    ../../../../AnyID_Embedded/V1.1.0/STM32_lib_V3.3/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../src/: AnyID_CanFestival_Can_HL.c AnyID_CanFestival_Device.c AnyID_CanFestival_FRam.c AnyID_CanFestival_FRam_HL.c AnyID_CanFestival_Periph_HL.c AnyID_CanFestival_RS485.c AnyID_CanFestival_RS485_HL.c AnyID_CanFestival_RTC.c AnyID_CanFestival_SysCfg.c AnyID_CanFestival_SysTick_HL.c AnyID_CanFestival_Tim_HL.c AnyID_CanFestival_Uart_Receive.c AnyID_CanFestival_WDG_HL.c AnyID_FRam.c
    ../../../../AnyID_Embedded/V1.1.0/AnyID_lib_V1.1.0/src/: AnyID_Stdlib.c
    ../CanFestival/driver/: masterNormal.c
